* NGSPICE file created from adder16.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_4 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_2 abstract view
.subckt sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

.subckt adder16 VGND VPWR a[0] a[10] a[11] a[12] a[13] a[14] a[15] a[1] a[2] a[3]
+ a[4] a[5] a[6] a[7] a[8] a[9] b[0] b[10] b[11] b[12] b[13] b[14] b[15] b[1] b[2]
+ b[3] b[4] b[5] b[6] b[7] b[8] b[9] carry clk en rst_n sum[0] sum[10] sum[11] sum[12]
+ sum[13] sum[14] sum[15] sum[1] sum[2] sum[3] sum[4] sum[5] sum[6] sum[7] sum[8]
+ sum[9]
XTAP_TAPCELL_ROW_12_65 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_200_ net71 _064_ net54 VGND VGND VPWR VPWR _008_ sky130_fd_sc_hd__mux2_1
X_131_ net10 net26 VGND VGND VPWR VPWR _099_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_114_ net7 net23 VGND VGND VPWR VPWR _082_ sky130_fd_sc_hd__or2_1
XFILLER_18_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput42 net42 VGND VGND VPWR VPWR sum[15] sky130_fd_sc_hd__buf_2
XFILLER_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_56 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_130_ _095_ _097_ _092_ _093_ VGND VGND VPWR VPWR _098_ sky130_fd_sc_hd__o211ai_2
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_76 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_113_ net7 net23 VGND VGND VPWR VPWR _081_ sky130_fd_sc_hd__nand2_1
Xhold20 net47 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_6_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput43 net43 VGND VGND VPWR VPWR sum[1] sky130_fd_sc_hd__buf_2
Xrebuffer9 _039_ VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_8_57 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_77 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_189_ _101_ _018_ VGND VGND VPWR VPWR _057_ sky130_fd_sc_hd__or2_1
XFILLER_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_112_ net54 VGND VGND VPWR VPWR _080_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_8_Left_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold21 net50 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dlygate4sd3_1
Xoutput44 net44 VGND VGND VPWR VPWR sum[2] sky130_fd_sc_hd__buf_2
XFILLER_3_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_188_ _056_ _055_ net79 _080_ VGND VGND VPWR VPWR _004_ sky130_fd_sc_hd__a2bb2o_1
XTAP_TAPCELL_ROW_18_78 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold11 rst_n VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 net51 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dlygate4sd3_1
Xoutput45 net45 VGND VGND VPWR VPWR sum[3] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_11_Left_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_187_ _092_ _098_ _100_ _080_ VGND VGND VPWR VPWR _056_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_18_79 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload0 clknet_1_0__leaf_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__clkinv_2
X_239_ clknet_1_1__leaf_clk _015_ net53 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__dfrtp_1
Xhold12 net43 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__dlygate4sd3_1
Xhold23 net37 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dlygate4sd3_1
Xoutput35 net35 VGND VGND VPWR VPWR carry sky130_fd_sc_hd__buf_2
Xoutput46 net46 VGND VGND VPWR VPWR sum[4] sky130_fd_sc_hd__buf_2
XFILLER_7_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_186_ _092_ _098_ _100_ VGND VGND VPWR VPWR _055_ sky130_fd_sc_hd__a21oi_1
XFILLER_13_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_238_ clknet_1_1__leaf_clk _014_ net53 VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__dfrtp_1
X_169_ net64 _041_ VGND VGND VPWR VPWR _042_ sky130_fd_sc_hd__nand2_2
Xhold13 net35 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 net45 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dlygate4sd3_1
Xoutput47 net47 VGND VGND VPWR VPWR sum[5] sky130_fd_sc_hd__buf_2
Xoutput36 net36 VGND VGND VPWR VPWR sum[0] sky130_fd_sc_hd__buf_2
XFILLER_4_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_185_ _080_ net73 _054_ VGND VGND VPWR VPWR _003_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_0_40 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_168_ _025_ _029_ _032_ _040_ _024_ VGND VGND VPWR VPWR _041_ sky130_fd_sc_hd__o221a_1
X_237_ clknet_1_1__leaf_clk _013_ net53 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__dfrtp_1
Xhold25 net46 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_10_60 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold14 net39 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput48 net48 VGND VGND VPWR VPWR sum[6] sky130_fd_sc_hd__buf_2
Xoutput37 net37 VGND VGND VPWR VPWR sum[10] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_15_Left_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_0_Left_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_41 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_184_ net54 _098_ _053_ VGND VGND VPWR VPWR _054_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_3_Left_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_167_ _034_ _036_ _033_ VGND VGND VPWR VPWR _040_ sky130_fd_sc_hd__a21o_1
X_236_ clknet_1_1__leaf_clk _012_ net53 VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__dfrtp_1
Xhold15 net36 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_61 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold26 net40 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dlygate4sd3_1
X_219_ _080_ net41 VGND VGND VPWR VPWR _077_ sky130_fd_sc_hd__and2_1
Xoutput38 net38 VGND VGND VPWR VPWR sum[11] sky130_fd_sc_hd__buf_2
Xoutput49 net49 VGND VGND VPWR VPWR sum[7] sky130_fd_sc_hd__buf_2
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_183_ _092_ _093_ _095_ _097_ VGND VGND VPWR VPWR _053_ sky130_fd_sc_hd__a211o_1
XFILLER_9_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_235_ clknet_1_1__leaf_clk _011_ net53 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__dfrtp_1
XFILLER_1_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_166_ _022_ _020_ _032_ _035_ _038_ VGND VGND VPWR VPWR _039_ sky130_fd_sc_hd__a2111o_1
Xhold16 net49 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dlygate4sd3_1
X_218_ _086_ _046_ VGND VGND VPWR VPWR _076_ sky130_fd_sc_hd__nand2_1
X_149_ _103_ _105_ net58 _021_ _102_ VGND VGND VPWR VPWR _022_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_6_52 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput39 net39 VGND VGND VPWR VPWR sum[12] sky130_fd_sc_hd__buf_2
XFILLER_7_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_72 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_182_ _080_ net67 _052_ VGND VGND VPWR VPWR _002_ sky130_fd_sc_hd__a21o_1
XFILLER_13_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout52 net34 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_4
XFILLER_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_165_ _036_ _037_ VGND VGND VPWR VPWR _038_ sky130_fd_sc_hd__nand2_1
X_234_ clknet_1_0__leaf_clk _010_ net52 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__dfrtp_1
Xhold17 net48 VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dlygate4sd3_1
X_148_ _109_ _111_ _108_ VGND VGND VPWR VPWR _021_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_6_53 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_217_ _075_ _074_ net81 _080_ VGND VGND VPWR VPWR _014_ sky130_fd_sc_hd__a2bb2o_4
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_73 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_181_ _097_ _051_ net54 VGND VGND VPWR VPWR _052_ sky130_fd_sc_hd__and3b_1
XFILLER_13_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout53 net34 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__buf_2
XFILLER_1_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_164_ net15 net31 VGND VGND VPWR VPWR _037_ sky130_fd_sc_hd__or2_1
X_233_ clknet_1_0__leaf_clk _009_ net52 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__dfrtp_1
Xhold18 net44 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_7_Left_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_147_ _092_ _098_ _099_ _091_ _019_ VGND VGND VPWR VPWR _020_ sky130_fd_sc_hd__a311o_1
X_216_ _088_ _043_ _045_ _080_ VGND VGND VPWR VPWR _075_ sky130_fd_sc_hd__a31o_1
XFILLER_7_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout54 net33 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_4
X_180_ net1 net17 _094_ _096_ VGND VGND VPWR VPWR _051_ sky130_fd_sc_hd__a22o_1
X_232_ clknet_1_0__leaf_clk _008_ net52 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__dfrtp_1
X_163_ net15 net31 VGND VGND VPWR VPWR _036_ sky130_fd_sc_hd__nand2_1
XFILLER_1_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold19 net38 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dlygate4sd3_1
X_146_ _018_ _110_ _107_ VGND VGND VPWR VPWR _019_ sky130_fd_sc_hd__or3_4
X_215_ _088_ _043_ _045_ VGND VGND VPWR VPWR _074_ sky130_fd_sc_hd__a21oi_1
X_129_ net1 net17 _094_ _096_ VGND VGND VPWR VPWR _097_ sky130_fd_sc_hd__and4_1
Xfanout55 net33 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_2
XFILLER_13_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_231_ clknet_1_0__leaf_clk _007_ net52 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__dfrtp_1
X_162_ _033_ _034_ VGND VGND VPWR VPWR _035_ sky130_fd_sc_hd__nand2b_1
XFILLER_10_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput1 a[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_1
X_145_ _111_ _017_ VGND VGND VPWR VPWR _018_ sky130_fd_sc_hd__nand2_1
X_214_ net69 _073_ net55 VGND VGND VPWR VPWR _013_ sky130_fd_sc_hd__mux2_1
X_128_ net8 net24 VGND VGND VPWR VPWR _096_ sky130_fd_sc_hd__or2_1
XFILLER_7_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_46 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_66 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_230_ clknet_1_0__leaf_clk _006_ net52 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__dfrtp_1
X_161_ net16 net32 VGND VGND VPWR VPWR _034_ sky130_fd_sc_hd__nand2_1
Xinput2 a[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_1
X_144_ net11 net27 VGND VGND VPWR VPWR _017_ sky130_fd_sc_hd__or2_1
X_213_ _090_ _042_ VGND VGND VPWR VPWR _073_ sky130_fd_sc_hd__xor2_1
X_127_ _094_ VGND VGND VPWR VPWR _095_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_3_47 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_67 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_160_ net16 net32 VGND VGND VPWR VPWR _033_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 a[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
X_143_ net11 net27 VGND VGND VPWR VPWR _111_ sky130_fd_sc_hd__nand2_1
X_212_ net74 _072_ net55 VGND VGND VPWR VPWR _012_ sky130_fd_sc_hd__mux2_1
X_126_ net8 net24 VGND VGND VPWR VPWR _094_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_14_Left_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_38 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_58 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput4 a[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_2_Left_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_142_ _108_ _109_ VGND VGND VPWR VPWR _110_ sky130_fd_sc_hd__nand2b_1
XFILLER_10_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_211_ _027_ _071_ VGND VGND VPWR VPWR _072_ sky130_fd_sc_hd__xnor2_1
X_125_ net9 net25 VGND VGND VPWR VPWR _093_ sky130_fd_sc_hd__or2_1
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_39 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_59 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput5 a[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
X_141_ net12 net28 VGND VGND VPWR VPWR _109_ sky130_fd_sc_hd__nand2_1
X_210_ _030_ _033_ _068_ _029_ VGND VGND VPWR VPWR _071_ sky130_fd_sc_hd__o31ai_2
XFILLER_2_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_124_ net9 net25 VGND VGND VPWR VPWR _092_ sky130_fd_sc_hd__nand2_2
Xinput30 b[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__buf_6
XFILLER_16_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput6 a[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
X_140_ net12 net28 VGND VGND VPWR VPWR _108_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput20 b[12] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_1
Xinput31 b[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_1
X_123_ net10 net26 VGND VGND VPWR VPWR _091_ sky130_fd_sc_hd__nor2_1
XFILLER_11_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_18_Left_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput7 a[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
XFILLER_10_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_199_ _104_ _063_ VGND VGND VPWR VPWR _064_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_6_Left_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_122_ _088_ _089_ VGND VGND VPWR VPWR _090_ sky130_fd_sc_hd__and2_1
Xinput21 b[13] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
Xinput10 a[3] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_1
Xinput32 b[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_1
XFILLER_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput8 a[1] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
XFILLER_10_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_198_ net57 _061_ _105_ VGND VGND VPWR VPWR _063_ sky130_fd_sc_hd__o21ai_1
X_121_ net4 net20 VGND VGND VPWR VPWR _089_ sky130_fd_sc_hd__or2_1
Xinput33 en VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
Xinput22 b[14] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
Xinput11 a[4] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
Xclkbuf_1_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_14_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_42 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput9 a[2] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_1
XFILLER_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_197_ net72 _062_ net54 VGND VGND VPWR VPWR _007_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_120_ net4 net20 VGND VGND VPWR VPWR _088_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_11_62 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput23 b[15] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_1
Xinput12 a[5] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
Xinput34 net66 VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
XFILLER_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_1_43 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_196_ net56 _061_ VGND VGND VPWR VPWR _062_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_11_63 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput13 a[6] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_6
Xinput24 b[1] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_1
X_179_ net70 _050_ net55 VGND VGND VPWR VPWR _001_ sky130_fd_sc_hd__mux2_1
XFILLER_11_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_195_ _108_ _057_ _021_ VGND VGND VPWR VPWR _061_ sky130_fd_sc_hd__o21a_1
Xinput14 a[7] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_7_54 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput25 b[2] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_10_Left_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_178_ net1 net17 VGND VGND VPWR VPWR _050_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_17_74 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_13_Left_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_194_ net75 _060_ net54 VGND VGND VPWR VPWR _006_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_1_Left_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_55 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_177_ net54 _081_ _048_ _049_ VGND VGND VPWR VPWR _000_ sky130_fd_sc_hd__a31oi_1
Xinput26 b[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
Xinput15 a[8] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
X_229_ clknet_1_0__leaf_clk _005_ net52 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_17_75 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_193_ _110_ _059_ VGND VGND VPWR VPWR _060_ sky130_fd_sc_hd__xnor2_1
XFILLER_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput27 b[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_1
Xinput16 a[9] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
X_176_ net68 net54 VGND VGND VPWR VPWR _049_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_45 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_228_ clknet_1_1__leaf_clk _004_ net52 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__dfrtp_1
X_159_ _027_ _028_ _030_ VGND VGND VPWR VPWR _032_ sky130_fd_sc_hd__or3_1
XFILLER_5_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_192_ _111_ _057_ VGND VGND VPWR VPWR _059_ sky130_fd_sc_hd__nand2_1
XFILLER_2_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_175_ _047_ _084_ _083_ VGND VGND VPWR VPWR _048_ sky130_fd_sc_hd__a21o_1
Xinput28 b[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_1
Xinput17 b[0] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_1
XFILLER_8_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_158_ _028_ _030_ VGND VGND VPWR VPWR _031_ sky130_fd_sc_hd__nor2_1
X_227_ clknet_1_1__leaf_clk _003_ net53 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_17_Left_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_191_ _080_ net80 _057_ _058_ VGND VGND VPWR VPWR _005_ sky130_fd_sc_hd__a22o_1
XFILLER_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput29 b[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__buf_6
Xinput18 b[10] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__buf_1
X_174_ _043_ _088_ _044_ _087_ _086_ VGND VGND VPWR VPWR _047_ sky130_fd_sc_hd__a311o_1
XPHY_EDGE_ROW_5_Left_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_226_ clknet_1_0__leaf_clk _002_ net52 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__dfrtp_1
XFILLER_8_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_157_ net2 net18 VGND VGND VPWR VPWR _030_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_4_48 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_209_ net78 _070_ net55 VGND VGND VPWR VPWR _011_ sky130_fd_sc_hd__mux2_1
XFILLER_0_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_68 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_190_ _101_ _018_ _080_ VGND VGND VPWR VPWR _058_ sky130_fd_sc_hd__a21oi_1
XFILLER_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput19 b[11] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__buf_1
X_173_ _088_ _043_ _044_ _087_ VGND VGND VPWR VPWR _046_ sky130_fd_sc_hd__a31o_1
X_225_ clknet_1_1__leaf_clk _001_ net52 VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__dfrtp_1
X_156_ net2 net18 VGND VGND VPWR VPWR _029_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_4_49 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_139_ _106_ _104_ VGND VGND VPWR VPWR _107_ sky130_fd_sc_hd__or2_4
X_208_ _031_ _069_ VGND VGND VPWR VPWR _070_ sky130_fd_sc_hd__xor2_1
XFILLER_5_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_69 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_172_ _087_ _044_ VGND VGND VPWR VPWR _045_ sky130_fd_sc_hd__nand2b_1
XFILLER_0_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_155_ net2 net18 VGND VGND VPWR VPWR _028_ sky130_fd_sc_hd__and2_1
X_224_ clknet_1_1__leaf_clk _000_ net52 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__dfrtp_1
X_138_ net29 net13 VGND VGND VPWR VPWR _106_ sky130_fd_sc_hd__xnor2_4
X_207_ _033_ _068_ VGND VGND VPWR VPWR _069_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_171_ net5 net21 VGND VGND VPWR VPWR _044_ sky130_fd_sc_hd__nand2_1
X_240_ clknet_1_1__leaf_clk _016_ net53 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__dfrtp_1
Xrebuffer1 _106_ VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__dlygate4sd1_1
X_223_ net55 _079_ _048_ _078_ VGND VGND VPWR VPWR _016_ sky130_fd_sc_hd__a31o_1
X_154_ _024_ _026_ VGND VGND VPWR VPWR _027_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_9_Left_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_137_ net13 net29 VGND VGND VPWR VPWR _105_ sky130_fd_sc_hd__nand2_1
X_206_ _023_ _038_ _036_ _034_ VGND VGND VPWR VPWR _068_ sky130_fd_sc_hd__o211a_1
XFILLER_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_50 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_70 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_170_ _041_ _039_ _090_ VGND VGND VPWR VPWR _043_ sky130_fd_sc_hd__a21bo_1
Xrebuffer2 _106_ VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_153_ net3 net19 VGND VGND VPWR VPWR _026_ sky130_fd_sc_hd__or2_1
X_222_ _083_ _084_ _047_ VGND VGND VPWR VPWR _079_ sky130_fd_sc_hd__nand3_1
X_136_ net30 net14 VGND VGND VPWR VPWR _104_ sky130_fd_sc_hd__xnor2_4
X_205_ net77 _067_ net54 VGND VGND VPWR VPWR _010_ sky130_fd_sc_hd__mux2_1
XFILLER_9_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_119_ net5 net21 VGND VGND VPWR VPWR _087_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_5_51 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_12_Left_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_71 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer3 _107_ VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_3_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_152_ net3 net19 VGND VGND VPWR VPWR _025_ sky130_fd_sc_hd__nor2_1
XFILLER_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_221_ _080_ net42 VGND VGND VPWR VPWR _078_ sky130_fd_sc_hd__and2_1
X_204_ _035_ _066_ VGND VGND VPWR VPWR _067_ sky130_fd_sc_hd__xnor2_1
X_135_ net14 net30 VGND VGND VPWR VPWR _103_ sky130_fd_sc_hd__nor2_1
X_118_ _084_ _085_ VGND VGND VPWR VPWR _086_ sky130_fd_sc_hd__nand2_1
XFILLER_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_220_ net55 _076_ _047_ _077_ VGND VGND VPWR VPWR _015_ sky130_fd_sc_hd__a31o_1
X_151_ net3 net19 VGND VGND VPWR VPWR _024_ sky130_fd_sc_hd__nand2_1
XFILLER_0_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_134_ net14 net30 VGND VGND VPWR VPWR _102_ sky130_fd_sc_hd__nand2_1
X_203_ _023_ _038_ _036_ VGND VGND VPWR VPWR _066_ sky130_fd_sc_hd__o21ai_1
XFILLER_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_117_ net6 net22 VGND VGND VPWR VPWR _085_ sky130_fd_sc_hd__or2_1
Xoutput50 net50 VGND VGND VPWR VPWR sum[8] sky130_fd_sc_hd__buf_2
X_150_ _020_ _022_ VGND VGND VPWR VPWR _023_ sky130_fd_sc_hd__and2_1
XFILLER_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_202_ net76 _065_ net54 VGND VGND VPWR VPWR _009_ sky130_fd_sc_hd__mux2_1
X_133_ _092_ _098_ _099_ _091_ VGND VGND VPWR VPWR _101_ sky130_fd_sc_hd__a31o_1
XFILLER_9_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_116_ net6 net22 VGND VGND VPWR VPWR _084_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_16_Left_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput40 net40 VGND VGND VPWR VPWR sum[13] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_2_44 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput51 net51 VGND VGND VPWR VPWR sum[9] sky130_fd_sc_hd__buf_2
XFILLER_3_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_64 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_4_Left_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_201_ _023_ _038_ VGND VGND VPWR VPWR _065_ sky130_fd_sc_hd__xor2_1
X_132_ _091_ _099_ VGND VGND VPWR VPWR _100_ sky130_fd_sc_hd__nand2b_1
XFILLER_9_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_115_ _081_ _082_ VGND VGND VPWR VPWR _083_ sky130_fd_sc_hd__nand2_1
Xoutput41 net41 VGND VGND VPWR VPWR sum[14] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_2_45 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
.ends
