* NGSPICE file created from adder16.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_2 abstract view
.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_2 abstract view
.subckt sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_4 abstract view
.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_4 abstract view
.subckt sky130_fd_sc_hd__nor4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_4 abstract view
.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311ai_4 abstract view
.subckt sky130_fd_sc_hd__o311ai_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_2 abstract view
.subckt sky130_fd_sc_hd__o2111ai_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_4 abstract view
.subckt sky130_fd_sc_hd__o221ai_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

.subckt adder16 VGND VPWR a[0] a[10] a[11] a[12] a[13] a[14] a[15] a[1] a[2] a[3]
+ a[4] a[5] a[6] a[7] a[8] a[9] b[0] b[10] b[11] b[12] b[13] b[14] b[15] b[1] b[2]
+ b[3] b[4] b[5] b[6] b[7] b[8] b[9] carry clk en rst_n sum[0] sum[10] sum[11] sum[12]
+ sum[13] sum[14] sum[15] sum[1] sum[2] sum[3] sum[4] sum[5] sum[6] sum[7] sum[8]
+ sum[9]
XFILLER_22_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_0_Left_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_277_ clknet_1_0__leaf_clk _011_ net34 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__dfrtp_1
X_200_ _046_ _042_ _051_ VGND VGND VPWR VPWR _052_ sky130_fd_sc_hd__o21ai_1
XFILLER_17_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput42 net42 VGND VGND VPWR VPWR sum[15] sky130_fd_sc_hd__buf_1
XFILLER_13_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_276_ clknet_1_1__leaf_clk _010_ net34 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_259_ _048_ _052_ _053_ _103_ VGND VGND VPWR VPWR _097_ sky130_fd_sc_hd__a31o_1
XFILLER_20_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput43 net43 VGND VGND VPWR VPWR sum[1] sky130_fd_sc_hd__buf_1
XFILLER_22_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_275_ clknet_1_1__leaf_clk _009_ net34 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__dfrtp_1
XFILLER_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_258_ _048_ _052_ _053_ VGND VGND VPWR VPWR _096_ sky130_fd_sc_hd__a21oi_1
XFILLER_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_189_ _030_ _034_ _037_ _040_ VGND VGND VPWR VPWR _041_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_5_58 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_16_Left_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_78 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput44 net44 VGND VGND VPWR VPWR sum[2] sky130_fd_sc_hd__buf_1
XFILLER_15_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_19_Left_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_274_ clknet_1_1__leaf_clk _008_ net34 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__dfrtp_1
XFILLER_5_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Left_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_188_ _038_ _039_ VGND VGND VPWR VPWR _040_ sky130_fd_sc_hd__nor2_2
XFILLER_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_257_ _095_ net33 _094_ VGND VGND VPWR VPWR _013_ sky130_fd_sc_hd__a21oi_1
XFILLER_18_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_59 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_7_Left_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_79 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput45 net45 VGND VGND VPWR VPWR sum[3] sky130_fd_sc_hd__buf_1
XFILLER_15_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_273_ clknet_1_1__leaf_clk _007_ net34 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_20_Left_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_187_ net15 net31 VGND VGND VPWR VPWR _039_ sky130_fd_sc_hd__nor2_1
X_256_ _047_ _051_ VGND VGND VPWR VPWR _095_ sky130_fd_sc_hd__xnor2_1
Xclkload0 clknet_1_1__leaf_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__clkinv_2
X_239_ _081_ net33 _080_ _082_ VGND VGND VPWR VPWR _008_ sky130_fd_sc_hd__a31o_1
XFILLER_19_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput35 net35 VGND VGND VPWR VPWR carry sky130_fd_sc_hd__buf_1
Xoutput46 net46 VGND VGND VPWR VPWR sum[4] sky130_fd_sc_hd__buf_1
XFILLER_15_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_272_ clknet_1_1__leaf_clk _006_ net34 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__dfrtp_1
X_186_ net15 net31 VGND VGND VPWR VPWR _038_ sky130_fd_sc_hd__and2_1
XFILLER_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_255_ net33 net39 VGND VGND VPWR VPWR _094_ sky130_fd_sc_hd__nor2_1
X_238_ _103_ net49 VGND VGND VPWR VPWR _082_ sky130_fd_sc_hd__and2_1
X_169_ _131_ _132_ _018_ _020_ VGND VGND VPWR VPWR _021_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_6_60 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_21_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput36 net36 VGND VGND VPWR VPWR sum[0] sky130_fd_sc_hd__buf_1
Xoutput47 net47 VGND VGND VPWR VPWR sum[5] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_16_80 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_271_ clknet_1_0__leaf_clk _005_ net34 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__dfrtp_1
XFILLER_4_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_185_ net16 net32 VGND VGND VPWR VPWR _037_ sky130_fd_sc_hd__xor2_2
X_254_ _103_ _091_ _092_ _093_ VGND VGND VPWR VPWR _012_ sky130_fd_sc_hd__o31a_1
XFILLER_2_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_237_ net13 net29 _125_ _077_ VGND VGND VPWR VPWR _081_ sky130_fd_sc_hd__a211o_1
X_168_ net12 net28 VGND VGND VPWR VPWR _020_ sky130_fd_sc_hd__nor2_1
XFILLER_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_61 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput48 net48 VGND VGND VPWR VPWR sum[6] sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput37 net37 VGND VGND VPWR VPWR sum[10] sky130_fd_sc_hd__buf_1
XFILLER_21_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_81 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_270_ clknet_1_0__leaf_clk _004_ net34 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__dfrtp_1
XFILLER_4_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_253_ net33 net38 VGND VGND VPWR VPWR _093_ sky130_fd_sc_hd__or2_1
X_184_ _028_ _029_ _031_ _033_ VGND VGND VPWR VPWR _036_ sky130_fd_sc_hd__nor4_2
X_236_ _126_ _077_ _125_ VGND VGND VPWR VPWR _080_ sky130_fd_sc_hd__o21ai_1
X_167_ net12 net28 VGND VGND VPWR VPWR _019_ sky130_fd_sc_hd__nand2_1
XFILLER_19_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_219_ _103_ net44 _067_ VGND VGND VPWR VPWR _003_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_11_Left_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput49 net49 VGND VGND VPWR VPWR sum[7] sky130_fd_sc_hd__buf_1
Xoutput38 net38 VGND VGND VPWR VPWR sum[11] sky130_fd_sc_hd__buf_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_252_ _028_ _029_ _090_ VGND VGND VPWR VPWR _092_ sky130_fd_sc_hd__o21a_1
X_183_ _031_ _033_ VGND VGND VPWR VPWR _035_ sky130_fd_sc_hd__or2_1
X_235_ net33 net48 _079_ VGND VGND VPWR VPWR _007_ sky130_fd_sc_hd__o21a_1
XFILLER_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_166_ net12 net28 VGND VGND VPWR VPWR _018_ sky130_fd_sc_hd__and2_1
X_149_ net8 net24 net1 net17 VGND VGND VPWR VPWR _117_ sky130_fd_sc_hd__a22oi_4
X_218_ _066_ net33 _119_ VGND VGND VPWR VPWR _067_ sky130_fd_sc_hd__and3_1
Xoutput39 net39 VGND VGND VPWR VPWR sum[12] sky130_fd_sc_hd__buf_1
XFILLER_21_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_251_ _035_ _087_ _030_ _032_ VGND VGND VPWR VPWR _091_ sky130_fd_sc_hd__o211a_1
XFILLER_13_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_182_ _031_ _033_ VGND VGND VPWR VPWR _034_ sky130_fd_sc_hd__nor2_1
X_234_ _077_ _078_ net33 VGND VGND VPWR VPWR _079_ sky130_fd_sc_hd__o21ai_1
X_165_ _131_ _132_ VGND VGND VPWR VPWR _017_ sky130_fd_sc_hd__nand2_1
XFILLER_19_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_148_ net8 net24 VGND VGND VPWR VPWR _116_ sky130_fd_sc_hd__and2_1
X_217_ _112_ _114_ _115_ _117_ VGND VGND VPWR VPWR _066_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_54 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_250_ _035_ _087_ _032_ VGND VGND VPWR VPWR _090_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_13_74 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_181_ net2 net18 VGND VGND VPWR VPWR _033_ sky130_fd_sc_hd__nor2_1
X_233_ _126_ _127_ _019_ _076_ VGND VGND VPWR VPWR _078_ sky130_fd_sc_hd__o211a_1
X_164_ net27 net11 VGND VGND VPWR VPWR _132_ sky130_fd_sc_hd__nand2b_1
XFILLER_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_216_ _103_ _064_ _065_ _063_ VGND VGND VPWR VPWR _002_ sky130_fd_sc_hd__o31a_1
X_147_ net8 net24 VGND VGND VPWR VPWR _115_ sky130_fd_sc_hd__nor2_2
XFILLER_21_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_15_Left_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_55 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_18_Left_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_75 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_180_ net2 net18 VGND VGND VPWR VPWR _032_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_3_Left_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_232_ _019_ _076_ _128_ VGND VGND VPWR VPWR _077_ sky130_fd_sc_hd__a21boi_1
X_163_ net11 net27 VGND VGND VPWR VPWR _131_ sky130_fd_sc_hd__nand2b_1
X_215_ _115_ _116_ net1 net17 VGND VGND VPWR VPWR _065_ sky130_fd_sc_hd__o211a_1
X_146_ net9 net25 VGND VGND VPWR VPWR _114_ sky130_fd_sc_hd__or2_1
XFILLER_16_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_46 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_66 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_162_ net11 net27 VGND VGND VPWR VPWR _130_ sky130_fd_sc_hd__nand2_1
X_231_ net12 net28 _072_ VGND VGND VPWR VPWR _076_ sky130_fd_sc_hd__o21ai_1
XFILLER_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 a[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_2
X_214_ net1 net17 _115_ _116_ VGND VGND VPWR VPWR _064_ sky130_fd_sc_hd__a211oi_1
X_145_ net9 net25 VGND VGND VPWR VPWR _113_ sky130_fd_sc_hd__nor2_1
XFILLER_21_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_47 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_67 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_161_ _123_ _124_ _126_ _127_ VGND VGND VPWR VPWR _129_ sky130_fd_sc_hd__nor4_4
X_230_ _103_ _073_ _074_ _075_ VGND VGND VPWR VPWR _006_ sky130_fd_sc_hd__o31a_1
XFILLER_1_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput2 a[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_1
X_213_ net33 net43 VGND VGND VPWR VPWR _063_ sky130_fd_sc_hd__or2_1
X_144_ net9 net25 VGND VGND VPWR VPWR _112_ sky130_fd_sc_hd__nand2_2
XFILLER_7_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_48 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_160_ _126_ _127_ VGND VGND VPWR VPWR _128_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 a[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_10_68 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_212_ _062_ _061_ net36 _103_ VGND VGND VPWR VPWR _001_ sky130_fd_sc_hd__a2bb2o_1
X_143_ net10 net26 VGND VGND VPWR VPWR _111_ sky130_fd_sc_hd__or2_2
XFILLER_7_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_49 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput4 a[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_10_69 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_211_ net1 net17 _103_ VGND VGND VPWR VPWR _062_ sky130_fd_sc_hd__a21o_1
X_142_ _106_ _108_ VGND VGND VPWR VPWR _110_ sky130_fd_sc_hd__nor2_1
XFILLER_10_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_10_Left_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput5 a[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_48 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_141_ _102_ net6 VGND VGND VPWR VPWR _109_ sky130_fd_sc_hd__nand2_1
X_210_ net1 net17 VGND VGND VPWR VPWR _061_ sky130_fd_sc_hd__nor2_1
XFILLER_21_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput30 b[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__buf_1
XFILLER_16_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_50 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput6 a[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
X_140_ net22 _101_ VGND VGND VPWR VPWR _108_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_269_ clknet_1_0__leaf_clk _003_ net34 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_11_70 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput31 b[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_1
Xinput20 b[12] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_51 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput7 a[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_1
XFILLER_18_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_268_ clknet_1_0__leaf_clk _002_ net34 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__dfrtp_1
X_199_ _049_ _050_ VGND VGND VPWR VPWR _051_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_11_71 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput32 b[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__buf_1
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput21 b[13] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__buf_1
Xinput10 a[3] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_22_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_14_Left_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_17_Left_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput8 a[1] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_2_Left_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_267_ clknet_1_0__leaf_clk _001_ net34 VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__dfrtp_1
X_198_ net20 net4 VGND VGND VPWR VPWR _050_ sky130_fd_sc_hd__and2b_1
XFILLER_2_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput33 en VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__buf_4
Xinput22 b[14] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_7_62 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
Xinput11 a[4] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_22_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_82 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput9 a[2] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_1
XFILLER_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_266_ clknet_1_0__leaf_clk _000_ net34 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__dfrtp_1
X_197_ net4 net20 VGND VGND VPWR VPWR _049_ sky130_fd_sc_hd__and2b_1
XFILLER_21_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput34 rst_n VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_8
Xinput12 a[5] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_1
Xinput23 b[15] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_7_63 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_249_ _088_ net33 _089_ VGND VGND VPWR VPWR _011_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_22_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_83 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_282_ clknet_1_0__leaf_clk _016_ net34 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__dfrtp_1
XFILLER_14_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_265_ _059_ _099_ net33 _100_ VGND VGND VPWR VPWR _016_ sky130_fd_sc_hd__a31o_1
X_196_ net4 net20 VGND VGND VPWR VPWR _048_ sky130_fd_sc_hd__nand2_1
Xinput13 a[6] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_1
XFILLER_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput24 b[1] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_4
XFILLER_11_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_248_ net33 net37 VGND VGND VPWR VPWR _089_ sky130_fd_sc_hd__nor2_1
X_179_ net2 net18 VGND VGND VPWR VPWR _031_ sky130_fd_sc_hd__and2_1
XFILLER_16_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_22_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_281_ clknet_1_0__leaf_clk _015_ net34 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__dfrtp_1
XFILLER_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_264_ _103_ net42 VGND VGND VPWR VPWR _100_ sky130_fd_sc_hd__and2_1
X_195_ _027_ _036_ _037_ _040_ _046_ VGND VGND VPWR VPWR _047_ sky130_fd_sc_hd__a41o_1
XPHY_EDGE_ROW_6_Left_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput14 a[7] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_1
Xinput25 b[2] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__buf_1
XFILLER_11_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_247_ _034_ _087_ VGND VGND VPWR VPWR _088_ sky130_fd_sc_hd__xor2_1
XFILLER_14_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_178_ _028_ _029_ VGND VGND VPWR VPWR _030_ sky130_fd_sc_hd__nor2_1
XFILLER_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_9_Left_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_280_ clknet_1_0__leaf_clk _014_ net34 VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__dfrtp_1
XFILLER_14_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_22_Left_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_263_ _101_ _102_ _104_ _058_ VGND VGND VPWR VPWR _099_ sky130_fd_sc_hd__o211ai_1
X_194_ _044_ _036_ _045_ _028_ VGND VGND VPWR VPWR _046_ sky130_fd_sc_hd__a211o_1
XFILLER_11_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput15 a[8] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_1
X_177_ net3 net19 VGND VGND VPWR VPWR _029_ sky130_fd_sc_hd__nor2_1
X_246_ _027_ _037_ _040_ _044_ VGND VGND VPWR VPWR _087_ sky130_fd_sc_hd__a31oi_2
Xinput26 b[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
XFILLER_22_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_229_ net33 net47 VGND VGND VPWR VPWR _075_ sky130_fd_sc_hd__or2_1
XFILLER_17_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_4_56 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_76 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_262_ _098_ _057_ net41 _103_ VGND VGND VPWR VPWR _015_ sky130_fd_sc_hd__a2bb2o_1
X_193_ net3 net19 net2 net18 VGND VGND VPWR VPWR _045_ sky130_fd_sc_hd__o211a_1
XFILLER_11_22 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput16 a[9] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__dlymetal6s2s_1
X_245_ _085_ _086_ net33 net51 VGND VGND VPWR VPWR _010_ sky130_fd_sc_hd__o2bb2a_1
X_176_ net3 net19 VGND VGND VPWR VPWR _028_ sky130_fd_sc_hd__and2_1
Xinput27 b[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__buf_1
XFILLER_22_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_159_ net13 net29 VGND VGND VPWR VPWR _127_ sky130_fd_sc_hd__nor2_1
X_228_ _018_ _020_ _072_ VGND VGND VPWR VPWR _074_ sky130_fd_sc_hd__nor3_1
XFILLER_17_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_57 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_77 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_192_ net16 net32 _043_ VGND VGND VPWR VPWR _044_ sky130_fd_sc_hd__o21a_1
X_261_ _110_ _054_ _056_ _103_ VGND VGND VPWR VPWR _098_ sky130_fd_sc_hd__a31o_1
XFILLER_11_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_244_ _037_ _084_ net33 VGND VGND VPWR VPWR _086_ sky130_fd_sc_hd__o21a_1
X_175_ _022_ _026_ VGND VGND VPWR VPWR _027_ sky130_fd_sc_hd__nand2_2
Xinput17 b[0] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_2
Xinput28 b[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_1
X_158_ net13 net29 VGND VGND VPWR VPWR _126_ sky130_fd_sc_hd__and2_4
X_227_ _018_ _020_ _072_ VGND VGND VPWR VPWR _073_ sky130_fd_sc_hd__o21a_1
XFILLER_17_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_10_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_260_ net33 net40 _096_ _097_ VGND VGND VPWR VPWR _014_ sky130_fd_sc_hd__o22a_1
X_191_ net15 net31 net16 net32 VGND VGND VPWR VPWR _043_ sky130_fd_sc_hd__a22o_1
XFILLER_17_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_243_ _037_ _084_ VGND VGND VPWR VPWR _085_ sky130_fd_sc_hd__nand2_1
Xinput29 b[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__buf_1
X_174_ _125_ _128_ _023_ _025_ VGND VGND VPWR VPWR _026_ sky130_fd_sc_hd__a31oi_2
Xinput18 b[10] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__buf_1
XFILLER_11_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_157_ _123_ _124_ VGND VGND VPWR VPWR _125_ sky130_fd_sc_hd__nor2_1
X_226_ _111_ _121_ _017_ net27 net11 VGND VGND VPWR VPWR _072_ sky130_fd_sc_hd__a32o_1
X_209_ net35 net33 _060_ _059_ VGND VGND VPWR VPWR _000_ sky130_fd_sc_hd__a2bb2oi_1
XPHY_EDGE_ROW_13_Left_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_190_ _022_ _026_ _041_ VGND VGND VPWR VPWR _042_ sky130_fd_sc_hd__a21oi_4
X_242_ _027_ _040_ _038_ VGND VGND VPWR VPWR _084_ sky130_fd_sc_hd__a21oi_1
X_173_ net14 net30 _024_ VGND VGND VPWR VPWR _025_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_1_Left_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput19 b[11] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__buf_1
XFILLER_22_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_156_ net14 net30 VGND VGND VPWR VPWR _124_ sky130_fd_sc_hd__nor2_1
XFILLER_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_225_ _071_ _070_ net46 _103_ VGND VGND VPWR VPWR _005_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_3_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_208_ net7 net23 _103_ VGND VGND VPWR VPWR _060_ sky130_fd_sc_hd__a21oi_1
X_139_ _101_ net22 VGND VGND VPWR VPWR _107_ sky130_fd_sc_hd__nand2_1
XFILLER_15_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_241_ _083_ net50 _103_ VGND VGND VPWR VPWR _009_ sky130_fd_sc_hd__mux2_1
X_172_ net14 net30 net13 net29 VGND VGND VPWR VPWR _024_ sky130_fd_sc_hd__o211a_1
XFILLER_22_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_155_ net14 net30 VGND VGND VPWR VPWR _123_ sky130_fd_sc_hd__and2_4
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_224_ _111_ _121_ _017_ _103_ VGND VGND VPWR VPWR _071_ sky130_fd_sc_hd__a31o_1
X_138_ net6 _102_ VGND VGND VPWR VPWR _106_ sky130_fd_sc_hd__nor2_1
X_207_ _105_ _057_ _104_ VGND VGND VPWR VPWR _059_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_240_ _027_ _040_ VGND VGND VPWR VPWR _083_ sky130_fd_sc_hd__xor2_1
X_171_ _130_ _020_ _019_ VGND VGND VPWR VPWR _023_ sky130_fd_sc_hd__o21ai_1
XFILLER_11_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_223_ _111_ _121_ _017_ VGND VGND VPWR VPWR _070_ sky130_fd_sc_hd__a21oi_1
X_154_ _111_ _120_ VGND VGND VPWR VPWR _122_ sky130_fd_sc_hd__nand2_1
X_137_ _101_ _102_ VGND VGND VPWR VPWR _105_ sky130_fd_sc_hd__nor2_1
X_206_ _056_ _054_ _108_ _106_ VGND VGND VPWR VPWR _058_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_0_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_170_ _129_ _021_ _111_ _121_ VGND VGND VPWR VPWR _022_ sky130_fd_sc_hd__nand4_4
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_5_Left_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_153_ _113_ _117_ _115_ _120_ _112_ VGND VGND VPWR VPWR _121_ sky130_fd_sc_hd__o311ai_4
X_222_ _069_ _068_ net45 _103_ VGND VGND VPWR VPWR _004_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_136_ net7 net23 VGND VGND VPWR VPWR _104_ sky130_fd_sc_hd__xnor2_1
X_205_ _107_ _109_ _056_ _054_ VGND VGND VPWR VPWR _057_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_8_Left_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_52 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_Left_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_72 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_221_ _112_ _119_ _122_ _103_ VGND VGND VPWR VPWR _069_ sky130_fd_sc_hd__a31o_1
X_152_ net10 net26 VGND VGND VPWR VPWR _120_ sky130_fd_sc_hd__nand2_1
XFILLER_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_204_ net5 net21 _055_ VGND VGND VPWR VPWR _056_ sky130_fd_sc_hd__a21oi_1
X_135_ net33 VGND VGND VPWR VPWR _103_ sky130_fd_sc_hd__clkinv_4
XFILLER_0_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_52 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_53 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_151_ net8 net24 _112_ _114_ _118_ VGND VGND VPWR VPWR _119_ sky130_fd_sc_hd__o2111ai_2
X_220_ _112_ _119_ _122_ VGND VGND VPWR VPWR _068_ sky130_fd_sc_hd__a21oi_1
XFILLER_12_51 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_73 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_134_ net22 VGND VGND VPWR VPWR _102_ sky130_fd_sc_hd__inv_2
X_203_ net5 net21 net4 net20 VGND VGND VPWR VPWR _055_ sky130_fd_sc_hd__o211a_1
XFILLER_9_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput50 net50 VGND VGND VPWR VPWR sum[8] sky130_fd_sc_hd__buf_1
XFILLER_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_150_ net8 net24 net1 net17 VGND VGND VPWR VPWR _118_ sky130_fd_sc_hd__a22o_1
XFILLER_12_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_64 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_279_ clknet_1_1__leaf_clk _013_ net34 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__dfrtp_1
XFILLER_3_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_133_ net6 VGND VGND VPWR VPWR _101_ sky130_fd_sc_hd__inv_2
X_202_ _049_ _050_ _046_ _042_ _053_ VGND VGND VPWR VPWR _054_ sky130_fd_sc_hd__o221ai_4
XFILLER_0_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_84 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput51 net51 VGND VGND VPWR VPWR sum[9] sky130_fd_sc_hd__buf_1
XFILLER_17_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput40 net40 VGND VGND VPWR VPWR sum[13] sky130_fd_sc_hd__buf_1
XFILLER_7_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_278_ clknet_1_1__leaf_clk _012_ net34 VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_8_65 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_201_ net5 net21 VGND VGND VPWR VPWR _053_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_18_85 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_12_Left_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput41 net41 VGND VGND VPWR VPWR sum[14] sky130_fd_sc_hd__buf_1
.ends
